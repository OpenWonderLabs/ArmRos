Commit message: chore: update SDK interfaces and examples

File: onero_description/urdf/A1_dual/A1_dual.urdf (robot description, URDF)
Before this commit: robot A1_dual, 18 links, 17 joints
Joints:
- joint joint7-a1_r: axis 0 1 0 -> 0 0 1
